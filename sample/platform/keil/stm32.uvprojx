# Keil uVision project stm32.uvprojx, settings and files
target STM32F103ZETx (ARM-GNU)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103 +hex
  group stm32-platform-lib/hw/common
    ../../../src/stm32-platform/hw/common/: hw_common.c stm32_assert.c
  group stm32-platform-lib/hw/cortex-m3
    ../../../src/stm32-platform/hw/cortex-m3/: cortex-m3.c hw_can.c hw_gpio.c hw_nvic.c hw_rcc.c hw_scb.c hw_systick.c hw_usart.c
  group stm32-platform-lib/hal
    ../../../src/stm32-platform/hal/: hal_can.c hal_gpio.c hal_interrupt_vector_table.c hal_rcc.c hal_systick.c hal_usart.c
  group stm32-platform-lib/stm32
    ../../../src/stm32-platform/src/: can.c gpio.c interrupt_vector_table.c rcc.c systick.c usart.c
  group stm32-platform-lib/rtthread-nano/bsp
    ../../../src/rtthread-nano/bsp/: board_STM32F103.c board_STM32L475.c
    ../../../src/rtthread-nano/bsp/drivers/: drv_gpio.c
  group stm32-platform-lib/rtthread-nano/libcpu/common
    ../../../src/rtthread-nano/libcpu/arm/common/: backtrace.c showmem.c
  group stm32-platform-lib/rtthread-nano/libcpu/cortex-m3
    ../../../src/rtthread-nano/libcpu/arm/cortex-m3/: cpuport.c context_gcc.s
  group stm32-platform-lib/rtthread-nano/libcpu/cortex-m4
    ../../../src/rtthread-nano/libcpu/arm/cortex-m4/: cpuport.c context_gcc.s
  group stm32-platform-lib/rtthread-nano/src
    ../../../src/rtthread-nano/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c thread.c timer.c
  group stm32-platform-lib/rtthread-nano/components/cpuusage
    ../../../src/rtthread-nano/components/cpuusage/: cpuusage.c
  group stm32-platform-lib/rtthread-nano/components/finsh
    ../../../src/rtthread-nano/components/finsh/: cmd.c msh.c msh_parse.c shell.c
  group stm32-platform-lib/rtthread-nano/components/syslogd
    ../../../src/rtthread-nano/components/syslogd/: datacache.c syslogd.c
  group stm32-platform-lib/rtthread-nano/components/dfs
    ../../../src/rtthread-nano/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c msh_cmd.c
    ../../../src/rtthread-nano/components/dfs/filesystems/devfs/: devfs.c
  group stm32-platform-lib/rtthread-nano/components/drivers
    ../../../src/rtthread-nano/components/drivers/misc/: pin.c
  group stm32-platform-lib/cutils
    ../../../src/cutils/src/: properties.c retarget.c syslog.c
  group sample/app/device
    ../../device/: can.c led.c
  group sample/app/startup
    ../../startup/: boot.c startup.c
  group sample/app/src
    ../../src/: main.c
